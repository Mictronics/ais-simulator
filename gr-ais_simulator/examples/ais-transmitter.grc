options:
  parameters:
    author: Mictronics
    category: '[AIS Simulator]'
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
    title: Example AIS Transmitter
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: HackRF requires a minimum of 8Msps!
    value: 8e6
  states: {}
- name: sentence
  id: variable
  parameters:
    value: '''010010000011101011110111001110011000100000000000000000100000001011001000001011000101000110100010010100001101011001111011000011111111111011100101110011100000000000000110'''
  states: {}
- name: ais_simulator_build_frame_1
  id: ais_simulator_build_frame
  parameters:
    enable_input: 'True'
    enable_nrzi: 'True'
    len_tag_key: packet_len
    sentence: sentence
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '1337'
    type: TCP_SERVER
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: '161975000'
    gain0: '10'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [ais_simulator_build_frame_1, '0', digital_gmsk_mod_0, '0']
- [blocks_multiply_const_xx_0, '0', osmosdr_sink_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_xx_0, '0']
- [network_socket_pdu_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', ais_simulator_build_frame_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-352-g6efdc9d8
